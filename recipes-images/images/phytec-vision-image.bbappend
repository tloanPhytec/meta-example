IMAGE_INSTALL:append = " packagegroup-imx-ml demo-celebrity-face-match"

COMPATIBLE_MACHINE .= "|phyboard-pollux-imx8mp-3"
