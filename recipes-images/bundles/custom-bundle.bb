require recipes-images/bundles/phytec-headless-bundle.bb
