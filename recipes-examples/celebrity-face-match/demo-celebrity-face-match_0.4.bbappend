FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://demo-celebrity-face-match_pd24.1.0.patch \
           "
