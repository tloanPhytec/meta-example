COMPATIBLE_MACHINE .= "|phyboard-rigel-am67xx-1-mcu-spi1"
COMPATIBLE_MACHINE .= "|phyboard-rigel-am67xx-1-mcu-spi1-k3r5"
