COMPATIBLE_MACHINE .= "|phyboard-nash-imx93-0"
