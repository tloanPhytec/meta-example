COMPATIBLE_MACHINE:phyboard-zeta-imx7d-custom = "phyboard-zeta-imx7d-custom"
