FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:am62lxx-libra-fpsc-1= " \
    file://0001-undo-USB-hack-fix-unneeded-on-.2-Libra-CB.patch \
"
