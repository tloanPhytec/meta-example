RAUC_KEYRING_FILE = "${CERT_PATH}/cert.pem"
