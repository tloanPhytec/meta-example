CXXFLAGS:append = " -include cstdint"
