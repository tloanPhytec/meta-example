COMPATIBLE_MACHINE .= "|phyboard-lyra-am62xx-3-custom"
