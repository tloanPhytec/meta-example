COMPATIBLE_MACHINE .= "|phycore-am57xx-custom"
